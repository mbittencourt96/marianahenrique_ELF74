<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\blinky\blinky.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab1\Lab1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab2\Lab2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab3\Lab3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab4\lab4.ewp</path>
    </project>
    <batchBuild />
</workspace>
