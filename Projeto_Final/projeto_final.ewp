# IAR project projeto_final.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCIncludePath2: C:\Users\menin\Local Documents\TivaWare_C_Series-2.2.0.295; C:\Users\menin\Local Documents\marianahenrique_ELF74\Projeto Final\drivers; C:\Users\menin\Local Documents\marianahenrique_ELF74\Projeto Final\CMSIS-5.6.0\CMSIS\Core\Include; C:\Users\menin\Local Documents\marianahenrique_ELF74\Projeto Final\CMSIS-5.6.0\CMSIS\RTOS2\Include; C:\Users\menin\Local Documents\marianahenrique_ELF74\Projeto Final\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: projeto_final.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../TivaWare_C_Series-2.2.0.295/driverlib/ewarm/Exe/: driverlib.a
    src/: main.c RTX_Config.c RTX_Config.h rtx_lib.c system_TM4C1294.h system_TM4C1294_TW.c TM4C1294NCPDT.h
    CMSIS-5.6.0/CMSIS/RTOS2/RTX/Library/IAR/: RTX_CM4F.a
